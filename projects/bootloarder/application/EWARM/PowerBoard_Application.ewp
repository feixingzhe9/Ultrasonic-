# IAR project PowerBoard_Application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F103xE; xSIZE_OPTIMIZE; NO_MICO_RTOS; xMICO_DISABLE_WATCHDOG; DEBUG=1; NO_BLOCK_MENU; xMIKE_TEST
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\platforms\MCUs\STM32F1xx; ..\..\..\..\board; ..\..\..\..\kernel\RTOS\NoRTOS; ..\..\..\..\bootloader; ..\..\..\..\platforms\MCUs\STM32F1xx\EWARM; ..\..\..\..\platforms\Cortex-M3\CMSIS\Include; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries; ..\..\..\..\platforms\Cortex-M3\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\platforms\include; ..\..\..\..\include; ..\..\..\..\include\MiCODrivers; ..\..\..\..\board\PowerBoard_V2; ..\..\..\..\platforms\Cortex-M3; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals; ..\..\..\..\library\utilities; ..\..\..\..\kernel\security\Curve25519; ..\..\..\..\kernel\security; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\include; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\kernel\RTOS\FreeRTOS; ..\..\..\..\application\platform
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\kernel\RTOS\FreeRTOS
  OBJCOPY.OOCOutputFile: PowerBoard_Application1.hex
  ILINK.IlinkOutputFile: PowerBoard_Application.out
  ILINK.IlinkIcfFile: ..\..\..\..\board\PowerBoard_V2\applicationLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
configuration RTOS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F103xE; xSIZE_OPTIMIZE; xNO_MICO_RTOS; MICO_DISABLE_WATCHDOG
  ICCARM.CCIncludePath2: ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\platforms\MCUs\STM32F1xx; ..\..\..\..\board; ..\..\..\..\kernel\RTOS\NoRTOS; ..\..\..\..\bootloader; ..\..\..\..\platforms\MCUs\STM32F1xx\EWARM; ..\..\..\..\platforms\Cortex-M3\CMSIS\Include; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries; ..\..\..\..\platforms\Cortex-M3\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\platforms\include; ..\..\..\..\include; ..\..\..\..\include\MiCODrivers; ..\..\..\..\board\PowerBoard_V2; ..\..\..\..\platforms\Cortex-M3; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals; ..\..\..\..\library\utilities; ..\..\..\..\kernel\security\Curve25519; ..\..\..\..\kernel\security; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\include; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\kernel\RTOS\FreeRTOS
  OBJCOPY.OOCOutputFile: PowerBoard_Application.bin
  ILINK.IlinkIcfFile: E:\SuperMcuOS\board\PowerBoard_V2\applicationLinkerForIAR.icf
configuration test (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: PowerBoard_Application.bin
  ILINK.IlinkIcfFile: as above
configuration CookyPlus (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\platforms\MCUs\STM32F1xx; ..\..\..\..\board; ..\..\..\..\kernel\RTOS\NoRTOS; ..\..\..\..\bootloader; ..\..\..\..\platforms\MCUs\STM32F1xx\EWARM; ..\..\..\..\platforms\Cortex-M3\CMSIS\Include; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries; ..\..\..\..\platforms\Cortex-M3\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\platforms\include; ..\..\..\..\include; ..\..\..\..\include\MiCODrivers; ..\..\..\..\board\PowerBoard_V2; ..\..\..\..\platforms\Cortex-M3; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals; ..\..\..\..\library\utilities; ..\..\..\..\kernel\security\Curve25519; ..\..\..\..\kernel\security; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\include; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\kernel\RTOS\FreeRTOS; ..\..\..\..\application\cooky_plus\platform; ..\..\..\..\application\cooky_plus\
  OBJCOPY.OOCOutputFile: Application.bin
configuration CarsonPB_Master (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F103xE; xSIZE_OPTIMIZE; NO_MICO_RTOS; xMICO_DISABLE_WATCHDOG; DEBUG=1; NO_BLOCK_MENU
  ICCARM.CCIncludePath2: ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\platforms\MCUs\STM32F1xx; ..\..\..\..\board; ..\..\..\..\kernel\RTOS\NoRTOS; ..\..\..\..\bootloader; ..\..\..\..\platforms\MCUs\STM32F1xx\EWARM; ..\..\..\..\platforms\Cortex-M3\CMSIS\Include; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries; ..\..\..\..\platforms\Cortex-M3\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\platforms\include; ..\..\..\..\include; ..\..\..\..\include\MiCODrivers; ..\..\..\..\board\PowerBoard_Carson_Master; ..\..\..\..\platforms\Cortex-M3; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals; ..\..\..\..\library\utilities; ..\..\..\..\kernel\security\Curve25519; ..\..\..\..\kernel\security; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\include; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\kernel\RTOS\FreeRTOS; ..\..\..\..\application\carson_pb_master; ..\..\..\..\application\carson_pb_master\platform
  OBJCOPY.OOCOutputFile: CarsonC001M07A001.hex
configuration Carson_LEDS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: STM32F103xB; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\platforms\MCUs\STM32F1xx; ..\..\..\..\board; ..\..\..\..\kernel\RTOS\NoRTOS; ..\..\..\..\bootloader; ..\..\..\..\platforms\MCUs\STM32F1xx\EWARM; ..\..\..\..\platforms\Cortex-M3\CMSIS\Include; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries; ..\..\..\..\platforms\Cortex-M3\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\platforms\include; ..\..\..\..\include; ..\..\..\..\include\MiCODrivers; ..\..\..\..\board\PowerBoard_Carson_LEDS; ..\..\..\..\platforms\Cortex-M3; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals; ..\..\..\..\library\utilities; ..\..\..\..\kernel\security\Curve25519; ..\..\..\..\kernel\security; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\include; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\kernel\RTOS\FreeRTOS; ..\..\..\..\application\carson_pb_leds; ..\..\..\..\application\carson_pb_leds\platform
  OBJCOPY.OOCOutputFile: LEDS.hex
  ILINK.IlinkIcfFile: ..\..\..\..\board\PowerBoard_Carson_LEDS\applicationLinkerForIAR.icf
  group Application
    ../../../../application/: Getline.c Update_for_OTA.c ymodem.c
  group Application/Carson_LEDS
    ../../../../application/carson_pb_leds/: application.c menu.c
  group Application/Carson_LEDS/platform
    ../../../../application/carson_pb_leds/platform/: serial_leds.c serial_leds.h serial_uart.c serial_uart.h uart_protocol.c uart_protocol.h
  group Application/Carson_master
    ../../../../application/carson_pb_master/: application.c menu.c
  group Application/Carson_master/platform
    ../../../../application/carson_pb_master/platform/: app_platform.c app_platform.h battery.c battery.h can_protocol.c can_protocol.h serial_uart.c serial_uart.h temp_reference.c temp_reference.h uart_protocol.c uart_protocol.h upgrade_flash.c upgrade_flash.h voltage_detect.c voltage_detect.h
  group Application/Cooky_Plus
    ../../../../application/cooky_plus/: application.c menu.c
  group Application/Cooky_Plus/platform
    ../../../../application/cooky_plus/platform/: app_platform.c app_platform.h can_protocol.c can_protocol.h protocol.h serial_leds.c serial_leds.h serial_uart.c serial_uart.h temp_reference.c uart_protocol.c upgrade_flash.c upgrade_flash.h voltage_detect.c voltage_detect.h
  group Board/Carson_PB_LEDS
    ../../../../board/PowerBoard_Carson_LEDS/: platform.c platform.h platform_config.h
  group Board/Carson_PB_Master
    ../../../../board/PowerBoard_Carson_Master/: board_init.c multi_channel_detection.c platform.c platform.h platform_config.h stm32f1xx_powerboard.c
  group Board/PowerBoard_V2
    ../../../../board/PowerBoard_V2/: backlight.h board_init.c key_switch.c multi_channel_detection.c platform.c platform.h platform_config.h stm32f1xx_powerboard.c stm32f1xx_powerboard.h tps611xx_bl.c
  group include
    ../../../../include/: common.h debug.h mico.h mico_platform.h mico_rtos.h mico_security.h mico_socket.h mico_system.h MiCOSRPServer.h
  group include/MicoDriver
    ../../../../include/MiCODrivers/: MiCODriverAdc.h MiCODriverCan.h MiCODriverFlash.h MiCODriverGpio.h MiCODriverI2c.h MiCODriverMFiAuth.h MiCODriverNanoSecond.h MiCODriverPwm.h MiCODriverRng.h MiCODriverRtc.h MiCODriverSpi.h MiCODriverUart.h MiCODriverWdg.h
  group kernel
    ../../../../kernel/RTOS/NoRTOS/: rtos.c
  group kernel/FreeRTOS
    ../../../../kernel/RTOS/FreeRTOS/: FreeRTOSConfig.h mico_rtos.c
    ../../../../kernel/RTOS/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group kernel/FreeRTOS/CMSIS_RTOS
    ../../../../kernel/RTOS/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group kernel/FreeRTOS/portable
    ../../../../kernel/RTOS/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../kernel/RTOS/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group libraries/utilities
    ../../../../library/utilities/: AESUtils.c CheckSumUtils.c LibMd5.c RingBufferUtils.c SecurityUtils.c StringUtils.c TLVUtils.c URLUtils.c
  group Platform/Cortex-M3
    ../../../../platforms/Cortex-M3/: crt0_EWARM.c hardfault.c
  group Platform/EWARM
    ../../../../platforms/EWARM/: Retarget.c
  group Platform/STM32F1xx
    ../../../../platforms/MCUs/: mico_platform_common.c
    ../../../../platforms/MCUs/STM32F1xx/: platform_init.c
  group Platform/STM32F1xx/EWARM
    ../../../../platforms/MCUs/STM32F1xx/EWARM/: startup_stm32f103x8_application_EWARM.s startup_stm32f103xe_application_EWARM.s
  group Platform/STM32F1xx/Peripherals
    ../../../../platforms/MCUs/STM32F1xx/peripherals/: nbosDriverFlash.c platform_adc.c platform_can.c platform_flash.c platform_gpio.c platform_mcu_powersave.c platform_pwm.c platform_uart.c platform_watchdog.c
  group Platform/STM32F1xx/Peripherals/Libraries
    ../../../../platforms/MCUs/STM32F1xx/peripherals/libraries/: stm32f1xx_hal_conf.h system_stm32f1xx.c
  group Platform/STM32F1xx/Peripherals/Libraries/STM32F1xx_HAL_Driver
    ../../../../platforms/MCUs/STM32F1xx/peripherals/libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
