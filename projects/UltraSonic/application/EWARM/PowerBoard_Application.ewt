<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>RTOS</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>test</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <group>
      <name>platform</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\application\platform\app_platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\application\platform\app_platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\application\platform\can_protocol.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\application\platform\can_protocol.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\application\platform\fifo.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\application\platform\protocol.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\application\platform\serial_uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\application\platform\serial_uart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\application\platform\uart_protocol.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\application\platform\UltraSonic.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\application\platform\UltraSonic.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\application\platform\upgrade_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\application\platform\upgrade_flash.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\application\application.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\application\Getline.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\application\menu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\application\Update_for_OTA.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\application\ymodem.c</name>
    </file>
  </group>
  <group>
    <name>Board</name>
    <group>
      <name>UltraSonic</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\Ultrasonic\board_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\Ultrasonic\platform.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>include</name>
    <group>
      <name>MicoDriver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverAdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverCan.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverFlash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverGpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverI2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverMFiAuth.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverNanoSecond.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverPwm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverRng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverRtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverSpi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverUart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverWdg.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\debug.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico_platform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico_rtos.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico_security.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico_socket.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico_system.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MiCOSRPServer.h</name>
    </file>
  </group>
  <group>
    <name>kernel</name>
    <group>
      <name>FreeRTOS</name>
      <group>
        <name>CMSIS_RTOS</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\kernel\RTOS\FreeRTOS\Source\CMSIS_RTOS\cmsis_os.c</name>
        </file>
      </group>
      <group>
        <name>portable</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\kernel\RTOS\FreeRTOS\Source\portable\MemMang\heap_4.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\kernel\RTOS\FreeRTOS\Source\portable\IAR\ARM_CM3\port.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\kernel\RTOS\FreeRTOS\Source\portable\IAR\ARM_CM3\portasm.s</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\kernel\RTOS\FreeRTOS\FreeRTOSConfig.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\kernel\RTOS\FreeRTOS\Source\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\kernel\RTOS\FreeRTOS\mico_rtos.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\kernel\RTOS\FreeRTOS\Source\queue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\kernel\RTOS\FreeRTOS\Source\tasks.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\kernel\RTOS\FreeRTOS\Source\timers.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\kernel\RTOS\NoRTOS\rtos.c</name>
    </file>
  </group>
  <group>
    <name>libraries</name>
    <group>
      <name>Drivers</name>
    </group>
    <group>
      <name>utilities</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\library\utilities\AESUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\library\utilities\CheckSumUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\library\utilities\LibMd5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\library\utilities\RingBufferUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\library\utilities\SecurityUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\library\utilities\StringUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\library\utilities\TLVUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\library\utilities\URLUtils.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Platform</name>
    <group>
      <name>Cortex-M3</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platforms\Cortex-M3\crt0_EWARM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platforms\Cortex-M3\hardfault.c</name>
      </file>
    </group>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platforms\EWARM\Retarget.c</name>
      </file>
    </group>
    <group>
      <name>STM32F1xx</name>
      <group>
        <name>EWARM</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\EWARM\startup_stm32f103xe_application_EWARM.s</name>
        </file>
      </group>
      <group>
        <name>Peripherals</name>
        <group>
          <name>Libraries</name>
          <group>
            <name>STM32F1xx_HAL_Driver</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_adc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_adc_ex.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_can.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_cec.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_cortex.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_crc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_dac.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_dac_ex.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_dma.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_eth.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_flash.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_flash_ex.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_gpio.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_gpio_ex.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_hcd.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_i2c.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_i2s.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_irda.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_iwdg.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_msp_template.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_nand.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_nor.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_pccard.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_pcd.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_pcd_ex.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_pwr.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rcc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rcc_ex.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rtc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rtc_ex.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_sd.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_smartcard.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_spi.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_spi_ex.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_sram.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_tim.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_tim_ex.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_uart.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_usart.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_wwdg.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_fsmc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_sdmmc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_usb.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\stm32f1xx_hal_conf.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\system_stm32f1xx.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\nbosDriverFlash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\platform_can.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\platform_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\platform_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\platform_mcu_powersave.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\platform_pwm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\platform_tim.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\platform_uart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\platform_watchdog.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\mico_platform_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platforms\MCUs\STM32F1xx\platform_init.c</name>
      </file>
    </group>
  </group>
</project>


