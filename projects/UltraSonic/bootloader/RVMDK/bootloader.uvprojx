# Keil uVision project bootloader.uvprojx, settings and files
target PowerBoard (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F103xB BOOTLOADER SIZE_OPTIMIZE NO_MICO_RTOS MICO_DISABLE_WATCHDOG
  c misc: --diag_suppress=1,1293,68
  c include: ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Inc;..\..\..\..\platforms\MCUs\STM32F1xx;..\..\..\..\board;..\..\..\..\kernel\RTOS\NoRTOS;..\..\..\..\bootloader;..\..\..\..\platforms\MCUs\STM32F1xx\RVMDK;..\..\..\..\platforms\Cortex-M3\CMSIS\Include;..\..\..\..\platforms\Cortex-M3\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\..\platforms\include;..\..\..\..\include;..\..\..\..\include\MiCODrivers;..\..\..\..\board\PowerBoard;..\..\..\..\platforms\Cortex-M3;..\..\..\..\platforms\MCUs\STM32F1xx\peripherals;..\..\..\..\library\utilities;..\..\..\..\kernel\security\Curve25519;..\..\..\..\kernel\security;..\..\..\..\platforms;..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\..\..\..\board\PowerBoard\bootloaderLinkerForKeil.sct
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
  group Bootloader
    ../../../../bootloader/: BootloaderEntrance.c Getline.c menu.c Update_for_OTA.c ymodem.c
  group Board/PowerBoard
    ../../../../board/PowerBoard/: platform.c platform.h platform_config.h
  group Platform/Cortex-M3
    ../../../../platforms/Cortex-M3/: crt0_RVMDK.c hardfault.c
  group Platform/RVMDK
    ../../../../platforms/RVMDK/: Retarget.c
  group Platform/MCU
    ../../../../platforms/MCUs/: mico_platform_common.c
  group Platform/MCU/STM32F1xx
    ../../../../platforms/MCUs/STM32F1xx/: platform_init.c
  group Platform/MCU/STM32F1xx/RVMDK
    ../../../../platforms/MCUs/STM32F1xx/RVMDK/: startup_stm32f2xx_bootloader_RVMDK.s
  group Platform/MCU/STM32F1xx/peripherals
    ../../../../platforms/MCUs/STM32F1xx/peripherals/: platform_flash.c platform_gpio.c platform_mcu_powersave.c platform_uart.c platform_watchdog.c
  group Platform/MCU/STM32F1xx/peripherals/Libraries
    ../../../../platforms/MCUs/STM32F1xx/peripherals/libraries/: system_stm32f1xx.c
    ../../../../platforms/MCUs/STM32F1xx/peripherals/libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group Libraries/utilities
    ../../../../library/utilities/: CheckSumUtils.c CheckSumUtils.h RingBufferUtils.c RingBufferUtils.h StringUtils.c StringUtils.h
  group MICO/RTOS
    ../../../../kernel/RTOS/NoRTOS/: rtos.c
